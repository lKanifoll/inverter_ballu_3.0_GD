# Keil uVision project inverter_ballu_gd.uvprojx, settings and files
target inverter_ballu_gd (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F330CB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: inverter_ballu_gd +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F330
  c include: ..\;..\SDK\CMSIS;..\SDK\CMSIS\GD\GD32F3x0\Include;..\SDK\GD32F3x0_standard_peripheral\Include;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../: gd32f3x0_it.c systick.c
    ../src/: main.c inverter.c crc32.cpp Pixels.cpp wifi.c
  group CMSIS
    ../SDK/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group STARTUP
    ../: startup_gd32f3x0.s
  group SDK
    ../SDK/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
